# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\BALANCE\CONTROL;..\BALANCE\DataScope_DP;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\MPU6050;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\USART2;..\LIB\STM32F10x_StdPeriph_Driver\inc;..\USER;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/DataScope_DP/: DataScope_DP.C
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/show/: show.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 4.3.0
